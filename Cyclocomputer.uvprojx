# Keil uVision project Cyclocomputer.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Cyclocomputer +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=8 wLevel=1
  c define: USE_STDPERIPH_DRIVER
  c include: .\Driver;.\Library;.\Peripherals;.\Start;.\System;.\User;.\Peripherals\0.96_OLED_IIC;.\Peripherals\LED;.\Peripherals\MPU6050;.\Peripherals\W25Q64;.\Peripherals\2.4_TFT_SPI;.\Peripherals\Key;.\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM3;.\FreeRTOS
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Driver
    ./Driver/: ADC.c ADC.h IIC.c IIC.h Serial.c Serial.h SPI.c SPI.h DMA.c DMA.h Input_Capture.c Input_Capture.h PWM.c PWM.h Timer.c Timer.h Timer_External_Clock.c Timer_External_Clock.h
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group Peripherals
    ./Peripherals/0.96_OLED_IIC/: 0.96_OLED_IIC.c 0.96_OLED_IIC.h 0.96_OLED_IIC_Font.h
    ./Peripherals/Key/: Key.c Key.h
    ./Peripherals/MPU6050/: MPU6050.c MPU6050.h MPU6050_Reg.h
    ./Peripherals/W25Q64/: W25Q64.c W25Q64.h W25Q64_Order.h
    ./Peripherals/2.4_TFT_SPI/: FONT.H pic.h test.c test.h 2.4TFT.c 2.4TFT.h
    ./Peripherals/Through_Beam_Sensor/: Through_Beam_Sensor.c Through_Beam_Sensor.h
    ./Peripherals/DC Motor/: DC_Motor.c DC_Motor.h
    ./Peripherals/Rotary Encoder/: Rotary_Encoder.c Rotary_Encoder.h
    ./Peripherals/Servo Motor/: Servo_Motor.c Servo_Motor.h
  group Start
    ./Start/: core_cm3.c core_cm3.h startup_stm32f10x_md.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group System
    ./System/: Delay.c Delay.h sys.c sys.h
  group User
    ./User/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h main.c
  group FreeRTOS/Source
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c FreeRTOSConfig.h
  group FreeRTOS/Other
    ./FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ./FreeRTOS/portable/MemMang/: heap_4.c
